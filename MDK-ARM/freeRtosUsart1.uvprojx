# Keil uVision project freeRtosUsart1.uvprojx, settings and files
target freeRtosUsart1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: freeRtosUsart1
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\Drivers\LSM303DLHC
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/HAL
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_uart.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_tim.c stm32f3xx_hal_i2c.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c
    ../Drivers/STM32F3xx_HAL_Driver/Inc/: stm32f3xx_hal_i2c.h
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c event_groups.c list.c croutine.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User
    ../Src/: main.c stm32f3xx_it.c freertos.c stm32f3xx_hal_msp.c stm32f3xx_hal_timebase_TIM.c text_output.c compas.c events_handler.c shell.c shell_cmd.c led_output.c
    ../Inc/: text_output.h compas.h events_handler.h led_output.h
  group Driver/LSM303DLHC
    ../Drivers/LSM303DLHC/: lsm303dlhc_driver.c
software components: CMSIS:CORE 4.1.0
